DESCRIPTION = "Mini X session files for poky"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI = "file://mini-x-session"

