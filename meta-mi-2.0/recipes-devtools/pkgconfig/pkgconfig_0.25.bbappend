FILESEXTRAPATHS_append := "${THISDIR}/${PN}:"
SRC_URI += "file://allow_documented_environment_variables_in_autoconf.patch"
