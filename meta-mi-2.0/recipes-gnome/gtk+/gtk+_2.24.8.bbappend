DEPENDS += "cups"
RDEPENDS += "cups"
EXTRA_OECONF += "--enable-cups"

