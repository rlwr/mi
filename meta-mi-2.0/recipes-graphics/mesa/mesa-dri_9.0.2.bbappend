# Make libva happy
PROVIDES += " virtual/mesa"
