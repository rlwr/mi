FILESEXTRAPATHS_append := "${THISDIR}/files:"
SRC_URI_append += " file://no-grsec.scc"
