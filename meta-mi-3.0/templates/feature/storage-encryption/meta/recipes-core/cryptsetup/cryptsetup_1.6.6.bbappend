# to remove the circular dependency between cryptsetup and ramfs. RRECOMMENDS flag is optional

RRECOMMENDS_${PN} = ""


