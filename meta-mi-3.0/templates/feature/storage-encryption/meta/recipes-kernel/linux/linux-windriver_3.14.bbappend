FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://encrypt-root-support.scc;md5=46c45950fb6faf01174b26edc8fbe8d1"
