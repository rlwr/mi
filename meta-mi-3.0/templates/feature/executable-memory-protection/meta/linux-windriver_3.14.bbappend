FILESEXTRAPATHS_append := "${THISDIR}/files:"
SRC_URI_append += " file://exec-memory-protection.scc"
