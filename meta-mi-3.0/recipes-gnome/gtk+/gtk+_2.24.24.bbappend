DEPENDS_append = " cups "
RDEPENDS_append_${PN} = " cups "
EXTRA_OECONF += "--enable-cups"

